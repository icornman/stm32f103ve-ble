# Keil uVision project STM32F103VE_BLE.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103VE_BLE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src;.\src\Tools;.\src\USART;.\src\HM19
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./src/Main/: main.c main.h
  group USART
    ./src/USART/: usart.c usart.h
  group HM19
    ./src/HM19/: hm19.c hm19.h
  group Tools
    ./src/Tools/: tools.c tools.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
